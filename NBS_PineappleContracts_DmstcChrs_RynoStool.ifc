Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-11-28T11:59:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Nov 28 11:59:20 2019* Host: NCL-PI07* Database: C:\Users\WhittakL\AppData\Local\Temp\{56A06D4E-844B-46B0-8F56-EAB7837DB2D7}\ifc* Database version: 5507* Database creation date: Thu Nov 28 11:59:20 2019* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Nov 28 11:59:20 2019* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Nov 28 11:59:20 2019* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: RynoStool, NBS_PineappleContracts_DmstcChrs_RynoStool:RynoStool:304316
In: Level 0
Type - ElementType: RynoStool; Classification: Pr_40_50_12_85 (Uniclass2015); Material: NBS_PineappleContracts_IconPurple
Type - BOS_General - Author: NBS; BIMObjectName: NBS_PineappleContracts_DomesticChairs_RynoStool; ManufacturerName: Pineapple Contracts; ManufacturerURL: www.pineapplecontracts.com; NBSCertification: www.nationalbimlibrary.com/cert/jvpc4dig; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: https://uk.pineapplecontracts.com/product/ryno-stool/; Revision: n/a; Uniclass2015Title: Stools; Uniclass2015Code: Pr_40_50_12_85; Uniclass2015Version: Products v1.15; Version: 2
Type - NBS_Data - WeightOptions: 50 kg standard model, 25 kg midweight model, 5 kg lightweight model, contact manufacturer for additional weight options
Type - Pset_FurnitureTypeCommon - IsBuiltIn: no; MainColor: n/a; NominalDepth: 396 mm; NominalHeight: 470 mm; NominalLength: 0 mm; Reference: n/a; Style: Stool
Type - Pset_FurnitureTypeChair - HighestSeatingHeight: 470 mm; LowestSeatingHeight: 470 mm; SeatingHeight: 470 mm
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR
Type - COBie - NominalLength: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_50_12_85:Stools; CodePerformance: BS EN 16139: 2013 level 2, BS 5852:2006, UL94 HB flammability standards; Color: Blaze orange, epic blue, icon purple, vegas yellow, cool green, black, thunder grey, moonwalk grey, lime green, granite; Constituents: n/a; Description: Ryno stool; DurationUnit: year; ExpectedLife: n/a; Features: Weatherproof, fire retardant, floor fixing option available; Finish: n/a; Grade: n/a; Manufacturer: sales@pineapplecontracts.com; Material: UV stabilised polyethylene with anti-microbial additive; ModelNumber: 1RYS-FF-50; ModelReference: RynoStool; Name: DomesticChairs_RynoStool_PineappleContracts; NominalHeight: 470 mm; NominalWidth: 445 mm; ReplacementCost: n/a; Shape: Cylinder; Size: 470 x 445 x 396 mm; SustainabilityPerformance: 100% recyclable; WarrantyDescription: Lifetime guarantee against manufacturing faults; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
